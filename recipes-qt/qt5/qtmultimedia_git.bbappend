PACKAGECONFIG:append ?= " gstreamer"
